# Repository bsodmike/iot-sfe-esp8266-thing

File README.md:

## Getting Started with the ESP8266 Thing by SparkFun

* 1x [SparkFun ESP8266 Thing (WRL-13231)][SFE Thing]
* 1x [SparkFun FTDI Basic Breakout - 3.3V (DEV-09873)][SparkFun FTDI 3.3V]
* 1x 1000uF electrolytic decoupling-capacitor, polarised 16Vdc.

### Serial Debugging &mdash; That pesky DTR line

The [ESP8266 Thing Hookup Guide][ESP8266 Thing Hookup Guide] details functionality of the [DTR pin on-board the Thing][ESP8266 Thing Hookup Guide Hardware Overview] as

> Performs auto-reset, and puts the ESP8266 into bootloader mode. Connects through a capacitor to RESET, and a buffer to the ESP8266's GPIO0.

The ESP8266 is placed into bootloader mode by holding GPIO0 low and cycling power; to resume running the current program GPIO0 needs to be floating or tied to Vcc (3.3vdc).  A further note cautions,

> Of these jumpers, the DTR one is the most commonly modified. The DTR output of the FTDI Basic is used for two purposes: to reset the ESP8266 and pull GPIO0 low (putting the chip in bootloader mode). Keeping this jumper closed enables programming, but makes debugging via the Serial Monitor difficult, as the board will reset into bootloader mode whenever the terminal opens.

The hookup guide further [details how GPIO0 and the DTR line are used][Serial Debugging] to (along with RST) to auto-reboot the ESP8266 post uploading of a sketch

> GPIO0 – while perfectly capable as a digital I/O – serves a secondary purpose as a bootload/run-mode controller. When the ESP8266 boots up, it looks at GPIO0’s value to either enter the bootloader or start running the current program:

> To make it easy to program the ESP8266, we’ve tied GPIO0 to DTR (along with RST). When your programmer begins to upload a sketch, it’ll pull DTR low, in turn setting GPIO0 low and making the ESP8266 enter bootloader mode.

> Unfortunately, when you open a serial terminal, DTR usually goes low again. So every time you open the Arduino serial monitor, it’ll cause the ESP8266 to enter bootloader mode, instead of run-program mode. If you open up the serial monitor, and all you see is a line of gibberish, you’ve probably booted the ESP8266 into bootloader mode.

SparkFun also [propose a solution to allowing serial debugging][Serial Debugging] with the [FTDI Basic 3.3vdc][SparkFun FTDI 3.3V] + [ESP8266 Thing][SFE Thing],

> We’ve added the DTR jumper on the bottom of the board. You can cut the trace on the back and install a 2-pin male header combined with a 2-pin jumper. If the jumper is present, the board will be able to be programmed. Removing the jumper will enable serial terminal mode.

Rather than cutting traces, I took the approach of desoldering the DTR pin from the SMD 6-pin header at the bottom of the [FTDI Basic 3.3vdc][SparkFun FTDI 3.3V] board.

Having done so, I am able to tie GPIO0 to ground and cycle power &mdash; whenever I need to upload a new sketch to the ESP8266.

## Upgrading Onboard Flash Memory

The following details are based on this guide for upgrading [ESP-03 Flash Memory To 128 Mbit][ESP-03 Upgrade Flash Memory To 128 Mbit].  Here are a couple options, noting that the [Adesto chip][Adesto AT25SF321 Datasheet] is a direct replacement for the chips installed on the [SparkFun Thing WRL-13231][SFE Thing] &mdash;

* [Adesto AT25SF321][Adesto AT25SF321 Datasheet]: 32-Mbit, 2.5V Minimum SPI Serial Flash Memory with Dual-I/O and Quad-IO Support

* [Winbond 25Q128FV][Winbond 25Q128FV Datasheet]: 128M-bit Serial Flash Memory with uniform 4KB sectors and Dual/Quad SPI and QPI

I was able to locate the [Winbond 25Q128FV][AliExpress Winbond 25Q128FV] for sale on AliExpress, and thankfully offering world-wide delivery.

### Building NodeMCU with Vagrant

Vagrant can be used to quickly build the NodeMCU binary. You will need
to modify the `Vagrantfile` to ensure the synced folder `/iot/nodemcu-firmware_fork` within the Virtualbox VM points to your correct local-folder.

Note that [bsodmike/nodemcu-firmware](https://github.com/bsodmike/nodemcu-firmware) incorporates a [patch for the larger EEPROM size](https://github.com/bsodmike/nodemcu-firmware/commit/326c88bb4dd29271456725d62a393705e2cd27a7) in the `bsodmike-build` branch, which I plan to maintain against the `master` branch of [nodemcu/nodemcu-firmware](https://github.com/nodemcu/nodemcu-firmware).

```
$ git clone https://github.com/bsodmike/nodemcu-firmware
$ git checkout bsodmike-build
$ cd nodemcu-firmware

# Modify `app/include/user_modules.h` to select modules you wish included in your build.
# Ref: https://github.com/nodemcu/nodemcu-firmware/blob/master/app/include/user_modules.h

# Start Vagrant - this will take a while.
$ vagrant up
$ vagrant ssh

# You will now be SSH'd into the Virtualbox VM
vagrant@vagrant-ubuntu-vivid-64:~$ service docker start
vagrant@vagrant-ubuntu-vivid-64:~$ cd /iot/nodemcu-firmware_fork

# Use of the Docker Mount volume (-v) flag:
# https://docs.docker.com/engine/reference/commandline/run/#/mount-volume-v-read-only
#
# This sets the current directory, where you cloned the `bsodmike/nodemcu-firmware` repo above, at `/opt/nodemcu-firmware` within the container.
vagrant@vagrant-ubuntu-vivid-64:~$ docker run --rm -ti -e "FLOAT_ONLY=1" -v `pwd`:/opt/nodemcu-firmware marcelstoer/nodemcu-build
```

You will find the compiled binary in `nodemcu-firmware/bin` which is
ready to be flashed onto a new EEPROM chip.

### Flashing NodeMCU onto the new EEPROM chip.

```
# Put ESP8266 into Flash Mode:
# http://nodemcu.readthedocs.io/en/master/en/flash/#putting-device-into-flash-mode
#
# Flash your ESP8266:
# http://nodemcu.readthedocs.io/en/master/en/flash/#esptool
#
$ esptool.py --port <USB-port-with-ESP8266> write_flash 0x00000 <NodeMCU-firmware-directory>/bin/nodemcu_[integer|float]_<Git-branch>.bin
```

----------
[SFE Thing]: https://www.sparkfun.com/products/13231 "Thing WRL-13231"
[SparkFun FTDI 3.3V]: https://www.sparkfun.com/products/9873 "FTDI 3.3V"

[SFE Thing Github]: https://github.com/sparkfun/ESP8266_Thing "SparkFun ESP8266 Thing"
[ESP8266 Thing Hookup Guide]: https://learn.sparkfun.com/tutorials/esp8266-thing-hookup-guide/introduction "ESP8266 Thing Hookup Guide"
[ESP8266 Thing Hookup Guide Hardware Overview]: https://learn.sparkfun.com/tutorials/esp8266-thing-hookup-guide/hardware-overview "ESP8266 Thing Hookup Guide - Hardware Overview"

[Serial Debugging]: https://learn.sparkfun.com/tutorials/esp8266-thing-hookup-guide/using-the-arduino-addon#serial-dtr "Using Serial Monitor"

[AliExpress Winbond 25Q128FV]: http://www.aliexpress.com/item/25Q128FV/32675826288.html?spm=2114.13010208.99999999.267.TgW1G0 "AliExpress Winbond 25Q128FV"
[Winbond 25Q128FV Datasheet]: http://www.winbond.com/hq/product/code-storage-flash-memory/serial-nor-flash/?__locale=en&partNo=W25Q128FV "Winbond 25Q128FV Datasheet"
[Adesto AT25SF321 Datasheet]: http://www.adestotech.com/wp-content/uploads/DS-AT25SF321_047.pdf "Adesto AT25SF321 Datasheet"
[ESP-03 Upgrade Flash Memory To 128 Mbit]: http://www.instructables.com/id/ESP-03-Upgrade-Flash-Memory-to-128-M-Bit/?ALLSTEPS "ESP-03 Upgrade Flash Memory To 128 Mbit"

## EAGLE design SparkFun ESP8266 Thing - WRL-13231/Dimensions for CAD/SparkFun_ESP8266_Thing_dimensions_added.brd

Parts:
C1: 10uF; 0603-CAP
C2, C10: 0.1uF; 0603-CAP
C3, C4: 10pF; 0603-CAP
C5: 4.7uF; 0603-CAP
C6: 1.0uF; 0603-CAP
C7: 1.0uF; 0805
C8: 5.6pF; 0603-CAP
C9: 2.2uF; 0603-CAP
C11, C12: DNP; 0603-CAP
D1: YELLOW; LED-0603
D2: GREEN; LED-0603
D3: BAT20J; SOD-323
D4: RED; LED-0603
D5: DIODEBAS16; SOD-323
E1: ANTENNATRACE; TRACE_ANTENNA_2.4GHZ_25.7MM
FID1, FID2: FIDUCIAL1X2; FIDUCIAL-1X2
FRAME1: FRAME-LETTER; CREATIVE_COMMONS
J1: DNP; U.FL
JP1: USB; USB-B-MICRO-SMD_V03
JP2: LiPo; JST-2-PTH
JP3: M10"; 1X10
JP4: FTDI_BASICPTH; FTDI_BASIC
JP5: I2C; 1X04
L1, L2: DNP; 0603
LOGO1: SFE_LOGO_NAME.2_INCH; SFE_LOGO_NAME_.2
LOGO3: SFE_LOGO_FLAME.1_INCH; SFE_LOGO_FLAME_.1
LOGO4: OSHW-LOGOS; OSHW-LOGO-S
Q1: 2.5A/30V; SOT23-3
R1: 12k; 0603-RES
R2, R5, R8, R16: 200; 0603-RES
R3, R6, R7, R17: 10K; 0603-RES
R4: 2.0k; 0603-RES
R9: 0; 0603
R10: DNP; 0603-RES
R11, R13: 2.2k; 0603-RES
R15: 1K; 0603-RES
S1: SWITCH-SPDT-SMD-A; SWITCH-SPST-SMD-A
SJ1: JUMPER-PAD-2-NC_BY_TRACE; PAD-JUMPER-2-NC_BY_TRACE_YES_SILK
SJ2: JUMPER-PAD-3-NC_BY_TRACE; PAD-JUMPER-3-3OF3_NC_BY_TRACE_YES_SILK_FULL_BOX
SJ3: JUMPER-PTH-2-NC; PTH-JUMPER-NC_BOTTOM_NO_SILK
SJ4: JUMPER-PAD-2-NOYES_SILK; PAD-JUMPER-2-NO_YES_SILK
STANDOFF1, STANDOFF2, STANDOFF3, STANDOFF4: STAND-OFF
TP1, TP2, TP3, TP4, TP5, TP6, TP7: TEST-POINT3X5; PAD.03X.05
U1: ESP8266; QFN32
U2: MCP73831; SOT23-5
U3: AT25SF041-SOIC8; SO08
U4: AP2112K-3.3V; SOT23-5
U5: DNP; UDFN8
U6: DNP; SOT563-2
U7: DNP; FN-6
Y1: 26MHz; CRYSTAL-SMD-3.2X2.5

Connections:
ADC: JP3.9, U1.6 (TOUT/ADC)
ANT: J1.P$3 (SIGNAL), R10.1
CHIP_EN: JP3.10, R3.1, U1.7 (CHIP_EN)
DTR: C6.2, JP4.DTR (1), SJ1.2, SJ3.1
FTDI_VCC: JP4.VCC (4), SJ4.1
GND: C1.2, C2.2, C3.1, C4.1, C5.2, C7.2, C9.2, C10.2, C11.2, C12.2, E1.GND, E1.GND2 (GND), J1.P$1 (GND), J1.P$2 (GND), JP1.GND1 (GND), JP1.SHIELD1 (SHIELD), JP1.SHIELD2 (SHIELD), JP1.SHIELD3 (SHIELD), JP2.1, JP3.1, JP4.GND (6), JP5.1, L1.2, L2.2, R1.1, R4.1, R7.1, R8.2, R16.2, R17.1, S1.1 (O), U1.EP (GND), U2.2 (VSS), U3.4 (GND), U4.2 (GND), U5.4 (GND), U6.2 (GND), U6.4 (ADD0), U7.2 (ADDR), U7.3 (GND), Y1.2 (GND), Y1.4 (GND)
GPIO0: D5.A, JP3.4, R15.1, U1.15 (SPICS2/GPIO0)
GPIO2/SDA: JP5.3, R11.1, U1.14 (GPIO2), U5.5 (SDA), U6.6 (SDA), U7.6 (SDA)
GPIO4: JP3.5, U1.16 (GPIO4)
GPIO5: D2.A, JP3.3, U1.24 (GPIO5)
GPIO12: JP3.7, U1.10 (MTDI/SPIQ/GPIO12)
GPIO13: JP3.6, U1.12 (MTCK/SPID/GPIO13)
GPIO14/SCL: JP5.4, R13.1, U1.9 (MTMS/SPICLK/GPIO14), U5.6 (SCL), U6.1 (SCL), U7.4 (SCL)
GPIO15: R17.2, U1.13 (MTDO/SPICS/GPIO15)
GPIO16: JP3.8, U1.8 (XPD_DCDC/GPIO16)
LNA: C8.1, L1.1, U1.2 (LNA)
unnamed: R1.2, U1.31 (RES12K)
unnamed: C4.2, U1.28 (XTAL_IN), Y1.3 (2)
unnamed: C3.2, U1.27 (XTAL_OUT), Y1.1
unnamed: D4.C, R16.1
unnamed: C8.2, L2.1, R9.2, R10.2
unnamed: R5.2, U1.21 (SPICLK/SD_CLK)
unnamed: D5.C, SJ1.1, SJ3.2
unnamed: R11.2, SJ2.1
unnamed: R13.2, SJ2.3
unnamed: S1.2, U4.3 (EN)
unnamed: R4.2, U2.5 (PROG)
unnamed: D2.C, R8.1
unnamed: D1.C, R2.2
unnamed: R2.1, U2.1 (STAT)
RESET: C6.1, R6.1, TP7.P$1, U1.32 (EXT_RSTB)
SD_!HD!: TP4.P$1, U1.18 (SPIHD/SD_DATA_2), U3.7 (!HOLD!(D3))
SD_!WP!: TP1.P$1, U1.19 (SPIWP/SD_DATA_3), U3.3 (!WP!(D2))
SD_CLK: R5.1, TP3.P$1, U3.6 (SCK)
SD_CS0: TP6.P$1, U1.20 (SPICS0/SD_CMD), U3.1 (!CS!)
SD_SI: TP2.P$1, U1.23 (SPID/SD_DATA_1), U3.5 (SI(D0))
SD_SO: TP5.P$1, U1.22 (SPIQ/SD_DATA_0), U3.2 (SO(D1))
TRACE_ANT: E1.ANT (SIGNAL), R9.1
U0RXI: JP4.TXO (3), U1.25 (U0RXD)
U0TXO: JP4.RXI (2), U1.26 (U0TXD)
VBAT: C5.1, JP2.2, Q1.3 (D), U2.3 (VBAT)
VCC: C1.1, C2.1, C9.1, C10.1, C11.1, C12.1, D4.A, JP5.2, R3.2, R6.2, R15.2, SJ2.2, SJ4.2, U1.1 (VDDA), U1.3 (VDD3P3), U1.4 (VDD3P3), U1.11 (VDDPST), U1.17 (VDDPST), U1.29 (VDDD), U1.30 (VDDA), U3.8 (VCC), U4.5 (OUT), U5.8 (VCC), U6.5 (VCC), U7.1 (VDD)
VIN: C7.1, D3.C, JP3.2, Q1.2 (S), S1.3 (S), U4.1 (IN)
VUSB: D1.A, D3.A, JP1.VBUS1 (VCC), Q1.1 (G), R7.2, U2.4 (VIN)

Notes on the sheet:
Jim Lindblom
ECC108 (Authentication) TMP102 (Temperature) TSL2561 (Light)
Voltage Regulator & LiPo Charger
ESP8266 & 4Mb SPI Flash
Headers
Auto-Prog Jumper
v10
VCC Range: 1.7V->3.6V
VBAT should be a single- cell LiPo battery.
I2C pull-up enable/disable
SJ4 enables/disables powering board via FTDI
SJ3 and SJ1 allow auto-control of GPIO0 for programming. Disconnecting may be required to use serial terminal debugging.
I2C add.: 0x48
I2C add.: 0x60
I2C add.: 0x29
Population of the components in this section are optional. Default DNP.
Charge current: 500mA
DNP

Board: 2 copper layers, 55.4 x 25.9 mm, 73 parts (14 on the bottom side), 44 nets.

Other parts of the board:
LOGO5: SFE_LOGO_NAME.2_INCH; SFE_LOGO_NAME_.2

## Commit log

2016-07-08 Add initial documentation
2016-07-08 Serve images from within repo
2016-07-10 Add details on upgrading the flash memory IC and flashing with updated NodeMCU firmware
2016-07-11 Add notes on how to build NodeMCU binary using Vagrant
2016-07-11 Revise details for building NodeMCU using Vagrant
2016-07-11 Add note on using my fork of the nodemcu-firmware codebase with support for larger EEPROM sizes
2016-07-11 Add CAD dimensions for the Thing and the SFE project as submodule

Notices in the files:
parts and their libraries:
SparkFun-Capacitors: Licensing: Creative Commons ShareAlike 4.0 International - https://creativecommons.org/licenses/by-sa/4.0
SparkFun-Aesthetics: Released under the Creative Commons Attribution Share-Alike 4.0 License
SparkFun-Aesthetics: https://creativecommons.org/licenses/by-sa/4.0
